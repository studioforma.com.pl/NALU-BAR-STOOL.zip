Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Nalu-Bar Stool - IFC4.ifc
Time: 2024-10-23T15:29:28
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (4)
Name
 | Nalu-Bar Stool_0 - ObjectType: SketchupGroup
 | Nalu-Bar Stool_1 - ObjectType: SketchupGroup
 | Nalu-Bar Stool_2 - ObjectType: SketchupGroup
 | Nalu-Bar Stool_3 - ObjectType: SketchupGroup
